COMPATIBLE_MACHINE:append:orangepi-zero3 = "|orangepi-zero3"